# Keil uVision project iscrypt_sm1_lib_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODAT2
  output: iscrypt_sm1_lib_test
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Inc
  asm include: \\Cryptgraphy\CSDK ShareHeaders\XA1302\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Header
    ./Test/: iscrypt_sm1_test.h
  group Source
    ./: main.c
  group Test
    ./Test/: iscrypt_sm1_test.c
  group Lib
    ../../Lib/: iscrypt_sm1.LIB
