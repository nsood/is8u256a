# Keil uVision project iscrypt_sm2_ext_lib_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODAT2
  output: iscrypt_sm2_ext_lib_test
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ./: main.c
  group Lib
    ../../Lib/: iscrypt_random.LIB iscrypt_sm2.LIB iscrypt_sm2_ext.LIB iscrypt_sm3.LIB iscrypt_hash_bkpt_rst.LIB
