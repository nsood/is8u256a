# Keil uVision project RANDOM_LIB_TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODAT2
  output: RANDOM_LIB_TEST
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ./: main.c
  group Lib
    ../../Lib/: iscrypt_random.LIB
