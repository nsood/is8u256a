# Keil uVision project RSA_SRC_LIB_TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODAT2
  output: RSA_SRC_LIB_TEST
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ./: main.c
  group Lib
    ../../Lib/: iscrypt_rsa_sv.c iscrypt_random.LIB
    ../../Lib/B/: iscrypt_rsa_gen_key_kif.LIB iscrypt_rsa_kif.LIB
  group Test
    ./Test/: rsa_test.c rsa_test.h
