# Keil uVision project iscrypt_sha_lib_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODAT2
  output: iscrypt_sha1_sha256_lib_test
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\IncS
  group Source Group 1
    ./: STARTUP.A51
  group Header
    ./Test/: iscrypt_sha_test.h
  group Source
    ./: main.c
  group Test
    ./Test/: iscrypt_sha_test.c
  group Lib
    ../../LibS/: iscrypt_sha.LIB
