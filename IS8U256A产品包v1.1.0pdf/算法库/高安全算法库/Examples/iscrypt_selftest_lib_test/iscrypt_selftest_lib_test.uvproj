# Keil uVision project iscrypt_selftest_lib_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODP2
  output: iscrypt_selftest_lib_test
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\IncS
  group Source Group 1
    ./: STARTUP.A51
  group Header
    ./: iscrypt_selftest.h
  group Source
    ./: main.c
    ../../LibS/: iscrypt_selftest.c
  group Lib
    ../../LibS/: iscrypt_random.LIB iscrypt_rsa2048_sec.LIB iscrypt_selftest_sec.LIB iscrypt_sha.LIB iscrypt_sm1_sec.LIB iscrypt_sm2_sec.LIB iscrypt_sm3.LIB iscrypt_sm4_sec.LIB iscrypt_random_sec.LIB
