# Keil uVision project iscrypt_sm2_sec_lib_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODP2
  output: iscrypt_sm2_sec_lib_test
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Incs
  asm include: \\Cryptgraphy\csdk shareheaders\XA1302\asm_inc
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ./: main.c
  group Lib
    ../../LibS/: iscrypt_sm2_sec.LIB iscrypt_sm3.LIB
  group Test
    ./Test/: iscrypt_sm2_test.c iscrypt_sm2_test.h
