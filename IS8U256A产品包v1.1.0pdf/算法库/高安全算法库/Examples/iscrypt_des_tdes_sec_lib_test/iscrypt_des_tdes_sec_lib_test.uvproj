# Keil uVision project iscrypt_des_tdes_sec_lib_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODAT2
  output: iscrypt_des_tdes_sec_lib_test
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\IncS
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ./: main.c
  group Lib
    ../../LibS/: iscrypt_des_tdes_sec.LIB iscrypt_memory_sec.LIB iscrypt_random.LIB
  group Test
    ./Test/: iscrypt_des_sec_test.c iscrypt_tdes_sec_test.c iscrypt_des_sec_test.h iscrypt_tdes_sec_test.h
