# Keil uVision project CIU98320A_spi.uvproj, settings and files
target CIU98320A_spi (ARM-ADS)
  device: CIU98320A HED
  cpu: IRAM(0x0D0000-0x0D7FFF) IROM(0x00-0x004FFFF) CLOCK(32000000) CPUTYPE(ARM7TDMI)
  output: CIU98320A_spi +hex
  c flags: Optim=1
  c include: ..\Inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0xd0000 size 0x8000
  group Startup
    ../Startup/: Startup.s
  group Inc
    ../Inc/: CIU98320A.h CIU98320A_typesmacro.h CIU98320A_spi.h CIU98320A_sysclk.h
  group Source
    ../Source/: CIU98320A_interrupt.c CIU98320A_main.c CIU98320A_spi.c CIU98320A_sysclk.c CIU98320A_gpio.c
